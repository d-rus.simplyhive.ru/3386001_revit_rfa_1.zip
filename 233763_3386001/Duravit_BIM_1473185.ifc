Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: durastyle_washbasin_furniture_washbasin_compact_233763.ifc
Time: 2017-11-15T10:45:31
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2015
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFlowTerminal: DuraStyle Washbasin, furniture washbasin compact 233763
ePset_BIMobject_Lena - LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): DuraStyle Washbasin, furniture washbasin compact 233763; SKU (BO_prodsku): durastyle-washbasin-furniture-washbasin-compact-233763; ManufacturName (BO_Manufac): DURAVIT; BrandUrl (BO_brandurl): http://www.duravit.com; ProductFamily (BO_prodfam): DuraStyle; ProductGroup (BO_prodgroup): Washbasin, furniture washbasin compact; PublishDate (BO_publisdat): 1/11/2017; EditionNumber (BO_edinum): 1; Width (BO_width): 635; Height (BO_height): 0; Depth (BO_depth): 400; Weight (BO_weight): 15.5; QR (BO_boqrurl): http://bimobject.com/duravit/product/durastyle-washbasin-furniture-washbasin-compact-233763; ProductDataUrl (BO_prodaturl): bimobject.com/duravit/product/durastyle-washbasin-furniture-washbasin-compact-233763; ProductUrl (BO_producturl): http://pro.duravit.com/233763; InstallationInstructions (BO_montins): http://pro.duravit.com/233763; ProductCertification (BO_prodcert): http://pro.duravit.com/233763; TechnicalDescription (BO_techcert): http://pro.duravit.com/233763; BimObjectCategory (BO_bocat): Basins; IfcClassification (BO_ifcclas): Sanitary Terminal; UnspcCode (BO_unspc): 301815; Uniclass14Code (BO_uniclass_1_4_code): L721; Uniclass14Description (BO_uniclass_1_4_desc): Sanitary equipment; Uniclass20Code (BO_uniclass_2_0_code): PR-31-76; Uniclass20Description (BO_uniclass_2_0_desc): Sanitary Dispensing And Disposal Units; Uniclass2015Code (BO_uniclass2015_code): Pr_40_20_96; Uniclass2015Description (BO_uniclass2015_desc): Wash basins, sinks and troughs; NBSReference (BO_nbs_ref): 31-76; NBSReferenceDescription (BO_nbs_desc): Sanitary Dispensing And Disposal Units; OmniClassCode (BO_omniclass_code): 23-19 31 17; OmniClassDescription (BO_omniclass_name): Sanitary Room Units; MasterFormat2014Code (BO_masterformat2014_code): 22 45 26; MasterFormat2014Description (BO_masterformat2014_name): Eye/Face Wash Equipment; UniFormat2Code (BO_uniformat2_code): D2010; UniFormat2Description (BO_uniformat2_name): Plumbing Fixtures; RegionEurope (BO_europe): All; RegionNorthAmerica (BO_northamerica): All; RegionSouthAmerica (BO_southamerica): All; RegionMiddleEast (BO_middleeast): All; RegionAsia (BO_asia): All; RegionOceania (BO_oceania): All; RegionAfrica (BO_africa): All; RegionAntarctica (BO_antarctica): All
